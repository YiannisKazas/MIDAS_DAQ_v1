# Keil uVision project FX2_to_extsyncFIFO.uvproj, settings and files
target Target 1 (MCS-51)
  device: EZ-USB FX2 (CY7C68XXX) Cypress Semiconductor
  cpu: IRAM(0 - 0xFF) XRAM(0 - 0x3FF) CLOCK(48000000) MODDP2
  output: FX2_to_extsyncFIFO +hex
  AfterMake: C:\Keil\Hex2bix.exe
  c flags: Optimize=6 SizeSpeed=1
  group Source Group 1
    ./: fw.c dscr.a51 FX2_to_extsyncFIFO.c gpif.c USBJmpTb.OBJ EZUSB.LIB
